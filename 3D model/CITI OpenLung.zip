# Autodesk Inventor part: Castanha
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-03
Part Number: Castanha
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Castanha
Author: Administrator
## Design history (mm, degrees)
feature "Castanha"
body "Solid1"
